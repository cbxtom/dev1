options:
  parameters:
    author: Tom, DJ6TB
    generate_options: qt_gui
    id: SatDecode
    output_language: python
    run_options: run
    title: SatDecode
  states: {}

blocks:
- name: baudrate
  id: variable
  parameters:
    value: '2400'
  states: {}
- name: constellation_8apsk
  id: variable_constellation
  parameters:
    const_points: sym_points
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    precision: '8'
    rot_sym: '7'
    sym_map: sym_map
    type: calcdist
  states: {}
- name: dec1
  id: variable
  parameters:
    value: '8'
  states: {}
- name: decim1
  id: variable
  parameters:
    value: '25'
  states: {}
- name: decim2
  id: variable
  parameters:
    value: 100//decim1
  states: {}
- name: f_center
  id: variable_qtgui_entry
  parameters:
    comment: Center frequency [Hz] (typ. 1.500 Hz)
    gui_hint: 3,0,1,1
    label: Center frequency
    type: real
    value: '1500'
  states: {}
- name: f_cutoff
  id: variable_qtgui_entry
  parameters:
    comment: Cutoff frequency [Hz] (typ 1.500 Hz)
    gui_hint: 4,0,1,1
    label: Cutoff frequency
    type: real
    value: '1500'
  states: {}
- name: f_level1
  id: variable_qtgui_range
  parameters:
    comment: Level Reference 100 Hz
    gui_hint: 3,1,1,1
    label: Level Reference 100 Hz
    min_len: '50'
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.05'
  states: {}
- name: f_level2
  id: variable_qtgui_range
  parameters:
    comment: Level Reference 2.8 kHz
    gui_hint: 4,1,1,1
    label: Level Reference 2.8 kHz
    min_len: '50'
    start: '0'
    step: '0.05'
    stop: '1'
    value: '0.05'
  states: {}
- name: nfilt
  id: variable
  parameters:
    value: '64'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilt, nfilt, 1.0/sps, 0.2, int(ceil(15*sps*nfilt)))
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '6000'
  states: {}
- name: samp_rate_audio
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: samp_rate/baudrate
  states: {}
- name: sym_map
  id: variable
  parameters:
    value: '[0b000, 0b100, 0b001, 0b011, 0b010, 0b110, 0b111, 0b101]'
  states: {}
- name: sym_map_inv
  id: variable
  parameters:
    value: '[sym_map.index(a) for a in range(8)]'
  states: {}
- name: sym_points
  id: variable
  parameters:
    value: '[0] + list(np.exp(1j*2*np.pi*np.arange(7)/7) * np.sqrt(8/7))'
  states: {}
- name: variable_low_pass_filter_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: '1500'
    gain: '1.0'
    samp_rate: '48000'
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: variable_low_pass_filter_taps_1
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: f_cutoff
    gain: '1.0'
    samp_rate: '48000'
    width: '200'
    win: window.WIN_HAMMING
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1'
    max_gain: '4'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: f_level1
    comment: Reference 100 Hz
    freq: '100'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_audio
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: f_level2
    comment: Reference 2.8 kHz
    freq: '2800'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_audio
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: audio_source_0_0_0
  id: audio_source
  parameters:
    device_name: CABLE Output
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate_audio
    type: float
  states: {}
- name: blocks_wavfile_source_0_0_0_0
  id: blocks_wavfile_source
  parameters:
    comment: Wave Input
    file: QO-100-Multimedia-Bake#2.wav
    repeat: 'True'
  states: {}
- name: digital_symbol_sync_xx_0_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.005'
    max_dev: '0.01'
    nfilters: nfilt
    osps: '1'
    pfb_mf_taps: rrc_taps
    resamp_type: digital.IR_PFB_MF
    sps: '2.5'
    ted_gain: '0.5'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '1500'
    decim: '8'
    samp_rate: '48000'
    taps: variable_low_pass_filter_taps
    type: fcc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: f_center
    decim: '8'
    samp_rate: '48000'
    taps: variable_low_pass_filter_taps_1
    type: fcc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: f_center
    decim: '8'
    samp_rate: '48000'
    taps: variable_low_pass_filter_taps_1
    type: fcc
  states: {}
- name: freq_xlating_fir_filter_xxx_0_1_0_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: f_center
    decim: '8'
    samp_rate: '48000'
    taps: variable_low_pass_filter_taps_1
    type: fcc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import ceil
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 2,1,1,1
    name: 8APSK constellation
    size: int(0.5*baudrate)
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_audio/dec1
    fc: '1500'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0,1,1,1
    label1: Signal
    name: Spektrum
    type: complex
    ymax: '-20'
    ymin: '-70'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    alpha2: '0.25'
    bw: samp_rate_audio/dec1
    comment: Audio Spektrum -3...+3 kHz
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 0,0,1,1
    label1: Signal
    label2: 100 Hz
    label3: 2.8 kHz
    name: Audiospektrum
    nconnections: '3'
    type: float
    ymax: '-20'
    ymin: '-70'
  states: {}
- name: qtgui_freq_sink_x_0_1_0
  id: qtgui_freq_sink_x
  parameters:
    alpha2: '0.25'
    bw: samp_rate_audio/dec1
    fc: f_center
    fftsize: '1024'
    grid: 'True'
    gui_hint: 2,0,1,1
    label1: Signal
    label2: 100 Hz
    label3: 2,8 kHz
    name: Spektrum 3
    nconnections: '3'
    type: complex
    ymax: '-20'
    ymin: '-70'
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: dec1
    fbw: '0.4'
    interp: '1'
    type: fff
  states: {}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: dec1
    fbw: '0.4'
    interp: '1'
    type: fff
  states: {}
- name: rational_resampler_xxx_1_0_0
  id: rational_resampler_xxx
  parameters:
    decim: dec1
    fbw: '0.4'
    interp: '1'
    type: fff
  states: {}
- name: satellites_costas_loop_8apsk_cc_0
  id: satellites_costas_loop_8apsk_cc
  parameters:
    loop_bw: '0.02'
  states: {}
- name: satellites_rms_agc_0
  id: satellites_rms_agc
  parameters:
    alpha: '1e-2'
    reference: '1.0'
  states: {state: disabled}

connections:
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0_0, '0']
- [analog_agc_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_sig_source_x_1, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_1, '0', freq_xlating_fir_filter_xxx_0_1_0_0, '0']
- [analog_sig_source_x_1, '0', rational_resampler_xxx_1_0, '0']
- [analog_sig_source_x_1_0, '0', blocks_add_xx_0, '2']
- [analog_sig_source_x_1_0, '0', freq_xlating_fir_filter_xxx_0_1_0_1, '0']
- [analog_sig_source_x_1_0, '0', rational_resampler_xxx_1_0_0, '0']
- [blocks_add_xx_0, '0', freq_xlating_fir_filter_xxx_0_1, '0']
- [blocks_throttle_1, '0', qtgui_freq_sink_x_0_0, '2']
- [blocks_wavfile_source_0_0_0_0, '0', blocks_add_xx_0, '0']
- [blocks_wavfile_source_0_0_0_0, '0', freq_xlating_fir_filter_xxx_0_1_0, '0']
- [blocks_wavfile_source_0_0_0_0, '0', rational_resampler_xxx_1, '0']
- [digital_symbol_sync_xx_0_0, '0', satellites_costas_loop_8apsk_cc_0, '0']
- [freq_xlating_fir_filter_xxx_0_1, '0', analog_agc_xx_0, '0']
- [freq_xlating_fir_filter_xxx_0_1_0, '0', qtgui_freq_sink_x_0_1_0, '0']
- [freq_xlating_fir_filter_xxx_0_1_0_0, '0', qtgui_freq_sink_x_0_1_0, '1']
- [freq_xlating_fir_filter_xxx_0_1_0_1, '0', qtgui_freq_sink_x_0_1_0, '2']
- [rational_resampler_xxx_1, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_1_0, '0', qtgui_freq_sink_x_0_0, '1']
- [rational_resampler_xxx_1_0_0, '0', blocks_throttle_1, '0']
- [satellites_costas_loop_8apsk_cc_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.0
